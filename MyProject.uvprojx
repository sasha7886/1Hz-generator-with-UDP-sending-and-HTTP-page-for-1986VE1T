# Keil uVision project MyProject.uvprojx, settings and files
target MyProject (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR1986BE1T Milandr
  pack: Milandr.MDR1986BExx.1.4.2
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: MyProject +hex
  AfterMake: cmd /c copy .\Obj\*.hex .
  c flags: Optim=1 oTime=1 v6Lang=1 v6LangP=1
  c misc: --diag_suppress=47
  c include: .\Application;.\Libraries\CMSIS\CM1\CoreSupport;.\Libraries\CMSIS\CM1\DeviceSupport\MDR1986VE1T\inc;.\Libraries\CMSIS\CM1\DeviceSupport\MDR1986VE1T\startup\arm;.\Config;.\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;.\Libraries\MDR32F9Qx_StdPeriph_Driver\inc\USB_Library;.\Libraries\PT;.\Libraries\RTT;.\2.1.2\lwip\src\include\lwip;.\2.1.2\lwip\src\include;.\2.1.2\ports\1986BE1\;.\2.1.2\ports\1986BE1\Standalone;.\2.1.2\ports\1986BE1\arch;.\2.1.2\lwip\src\include\netif;.\2.1.2\lwip\src\apps\http;.\2.1.2\lwip\src\apps\http\fs;.\2.1.2\lwip\src\apps\http;\
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  scatter file: .\MDR1986VE1T.sct
  group MDR32F9Qx_FWLib
    ./Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_rst_clk.c MDR32F9Qx_eeprom.c MDR32F9Qx_port.c MDR32F9Qx_timer.c MDR32F9Qx_iwdg.c MDR32F9Qx_uart.c
  group User
    ./Application/: MDR32F9Qx_config.h MDR32F9Qx_board.h MDR1986VE1T_IT.h MDR1986VE1T_IT.c Main.c Application.h HW_Profile.h BiLED.h BiLED.c XTick.c XTick.h retarget.c net.c net.h netconf.c netconf.h PPS.c PPS.h eeprom_new.c eeprom_new.h
  group New Group
    ./2.1.2/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./2.1.2/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ./2.1.2/ports/1986BE1/Standalone/: ethernetif.c ethernetif.h
    ./2.1.2/lwip/src/netif/: ethernet.c
    ./2.1.2/lwip/src/apps/http/: altcp_proxyconnect.c fsdata.h http_client.c httpd.c httpd_structs.h fs.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.3.0, Drivers:DMA 1.3.0, Drivers:Ethernet 1.3.0, Drivers:SSP 1.3.0
